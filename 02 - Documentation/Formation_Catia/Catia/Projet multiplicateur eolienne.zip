# CATIA V5 part "Reference.CATPart"
Saved by CATIA V5R19 SP3, build 01-09-2009
Part number: Reference
Stored file links:
  C:\Users\Frédéric\Documents\WF\STSCPI 09-11\Projets\Projet multiplicateur eolienne\Maquette eolienne\Reference.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
AxisSystem1: origin (0, 0, 0), X (1, 0, 0), Y (0, 1, 0), Z (0, 0, 1)
Body1 (main body)